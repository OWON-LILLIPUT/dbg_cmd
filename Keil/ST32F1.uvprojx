# Keil uVision project ST32F1.uvprojx, settings and files
target ST32F1_keil (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ST32F1 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: KEIL_DEBUG,_GLOBAL_DEBUG_ENABLE,MCU_STM32F3_1KB
  c misc: --diag_suppress=1295
  c include: ..\code\SysBsp\ST32F1;..\code\SysBsp\ST32F1\libary;..\code\SysBsp\ST32F1\inc;..\code\SysApp;..\code\SysDebug\debug;..\code\Common;..\code\SysDebug\dbg_cmd;..\code\DevDriver\demo;..\code\Middlewares\fs\littlefs;..\code\DevDriver\nor_little_fs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep=*Handler
  group SysBsp
    ../code/SysBsp/ST32F1/libary/: STM32F10xR.LIB
    ../code/SysBsp/ST32F1/: stm32f10x_vector.s
    ../code/SysBsp/ST32F1/src/: stm32f10x_it.c bsp.c
  group SysApp
    ../code/SysApp/: main.c project.c
  group SysDebug
    ../code/SysDebug/dbg_cmd/: dbg_cmd.c
    ../code/SysDebug/debug/: myprint.c
  group Common
    ../code/Common/: queue.c
  group DevDriver
    ../code/DevDriver/demo/: demo.c
    ../code/DevDriver/nor_little_fs/: nor_little_fs.c
  group Middlewares/fs/littlefs
    ../code/Middlewares/fs/littlefs/: lfs.c lfs_util.c
target ST32F1_1K (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ST32F1_V +hex
  AfterMake: fromelf --bin --output ..\HexBin\ST32F1_V.bin .\obj\ST32F1_V.axf
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _GLOBAL_DEBUG_ENABLE,MCU_STM32F3_1KB
  c misc: --diag_suppress=1295
  c include: ..\code\SysBsp\ST32F1;..\code\SysBsp\ST32F1\libary;..\code\SysBsp\ST32F1\inc;..\code\SysApp;..\code\Common;..\code\SysDebug\debug;..\code\SysDebug\dbg_cmd;..\code\DevDriver\demo;..\code\DevDriver\nor_little_fs;..\code\Middlewares\fs\littlefs
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep=*Handler
target ST32F1_2K (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: ST32F1_V +hex
  AfterMake: as above
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _GLOBAL_DEBUG_ENABLE,MCU_STM32F3_2KB
  c misc: --diag_suppress=1295
  c include: ..\code\SysBsp\ST32F1;..\code\SysBsp\ST32F1\libary;..\code\SysBsp\ST32F1\inc;..\code\SysApp;..\code\Common;..\code\SysDebug\debug;..\code\SysDebug\dbg_cmd;..\code\Middlewares\fs\littlefs;..\code\DevDriver\demo;..\code\DevDriver\nor_little_fs
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep=*Handler
